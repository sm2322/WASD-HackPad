# Repository sm2322/WASD-HackPad

File README.md:

# WASD HACKPAD

WASD HACKPAD is my hackpad that includes the basic wasd keys to be used for playing games! 

## Features:
- Simple Three Peice case
- 4 Keycaps
- custom QMK firmware!

## CAD Model:
Everything fits together using simple slide-in supports, it may not be perfectly study but it should make it useable!

It has 3 separate printed pieces, and includes supports for the pcb

Made in Fusion360. Just learned it lol

## PCB
Behold my pcb, it stuggled to enter this world.

## Firmware Overview
This hackpad uses [QMK](https://qmk.fm/) firmware for everything. 

- The 4 keys can be used to play games!!
- I hate QMK and sorta delted all of my source files after building, which was a struggle on my mac that can't use Xcode bc it doesn't have admin permissions...
- BUT I HAVE THE BUILD AND IT BETTER WORK

## BOM:
Here should be everything you need to make this hackpad

- 4x Cherry MX Switches
- 4x DSA Keycaps
- 1x XIAO RP2040
- 1x Case (3 printed parts)

## Extra stuff
This is my first Hack Club project!!!!! Wish me luck in the future lol

## KiCad design PCB/Personal Keyboard.kicad_pcb

Parts:
SW1, SW2, SW3, SW4: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: MOUDLE-SEEEDUINO-XIAO; XIAO-Generic-Hybrid-14P-2.54-21X17.8MM

Connections:
GND: SW1.2, SW2.2, SW3.2, SW4.2, U1.13 (GND)
unnamed: SW2.1, U1.10 (PA5_A9_D9_MISO)
unnamed: SW1.1, U1.11 (PA6_A10_D10_MOSI)
unnamed: SW3.1, U1.9 (PA7_A8_D8_SCK)
unnamed: SW4.1, U1.8 (PB09_A7_D7_RX)

Board: 2 copper layers, 57.0 x 38.5 mm, 5 parts (1 on the bottom side), 5 nets.

File Production/BOM.csv:

"Id";"Designator";"Footprint";"Quantity";"Designation";"Supplier and ref";
1;"SW1, SW2, SW3, SW4";"SW_Cherry_MX_1.00u_PCB";4;"SW_Push";;;
2;"U1";"XIAO-Generic-Hybrid-14P-2.54-21X17.8MM";1;"MOUDLE-SEEEDUINO-XIAO";;;

## Commit log

2026-06-27 Init
2026-06-27 Move firmware build to Production folder
    Move wasdkeyboard_default.uf2 from Firmware/ to Production/ directory. Add explanatory notes indicating that firmware source files were deleted after building, with the compiled build artifact retain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
2026-06-27 Revise README for WASD HackPad project
    Updated README to provide detailed project information and features.
2026-06-28 Add PCB design assets
    Add four image assets for the bonus, CAD, PCB, and schematic views.
2026-06-28 Replace local image paths with GitHub links
    Updated images in README with links to GitHub assets.
2026-06-28 Remove unused asset images
    Delete obsolete PNG assets from `Assets/` that are no longer needed by the project.
2026-06-28 Fix image tags in README.md
    Updated image tags in README for better clarity.
2026-06-28 Add additional image to README
    Added a new image to the README for better visualization.
2026-06-28 Rename keyboard BOM CSV
    Move the personal keyboard CSV into the Production folder as `BOM.csv` to reflect its production use and location.
2026-06-28 Archive old STLs; add updated case parts
    Move existing Production/Case Bottom.stl, Case Lid.stl, and Case Wall.stl into Production/Old STLs/ to archive previous versions. Add new binary STL files Production/Updated Case Lid.stl and Producti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
2026-06-28 Updated Case Again
